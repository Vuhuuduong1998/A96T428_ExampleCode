# Keil uVision project A96T430_LDT1_Read.uvproj, settings and files
target Target 1 (MCS-51)
  device: M8051EW Mentor Graphics Co.
  cpu: IRAM(0 - 0xFF) XRAM(0-0xFFFF) IROM(0-0xFFFF) CLOCK(12000000) MOD517DP
  output: a96T428_LDT1_Read +hex
  c flags: SizeSpeed=1
  c include: .\src
  group USER
    ./src/: main.c flash_enter.a51 delay.c trim.c a96T428_clock.c a96T428_flash.c a96T428_gpio.c a96T428_usart1_uart.c a96T428_timer2.c
  group STARTUP
    ./src/: startup.a51
