# Keil uVision project A96T430_USI_I2C_SLAVE_MASTER_MLOST.uvproj, settings and files
target Target 1 (MCS-51)
  device: M8051EW Mentor Graphics Co.
  cpu: IRAM(0 - 0xFF) XRAM(0-0xFFFF) IROM(0-0xFFFF) CLOCK(12000000) MOD517DP
  output: a96T428_USI0_I2C_Salve_Master_Interrupt +hex
  c flags: Optimize=5 SizeSpeed=1
  c include: ..\..\..\..\..\Driver;.\src
  group USER
    ./src/: main.c delay.c
    ../../../../../Driver/: a96T428_clock.c a96T428_gpio.c a96T428_usi_i2c.c a96T428_usart1_uart.c
  group STARTUP
    ./src/: startup.a51
