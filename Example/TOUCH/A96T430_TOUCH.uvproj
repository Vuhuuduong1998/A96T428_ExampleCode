# Keil uVision project A96T430_TOUCH.uvproj, settings and files
target Target 1 (MCS-51)
  device: M8051EW Mentor Graphics Co.
  cpu: IRAM(0 - 0xFF) XRAM(0-0xFFFF) IROM(0-0xFFFF) CLOCK(12000000) MOD517DP
  output: a96T428_TOUCH +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: ..\..\Driver;.\src
  group USER
    ./src/: main.c delay.c
    ../../Driver/: a96T428_clock.c a96T428_gpio.c a96T428_touch.c
  group STARTUP
    ./src/: startup.a51
