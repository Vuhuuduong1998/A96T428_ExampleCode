# Keil uVision project A96T430_USART2_USART_MASTER.uvproj, settings and files
target Target 1 (MCS-51)
  device: M8051EW Mentor Graphics Co.
  cpu: IRAM(0 - 0xFF) XRAM(0-0xFFFF) IROM(0-0xFFFF) CLOCK(12000000) MOD517DP
  output: a96T428_USART2_USART_MASTER +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\..\..\..\Driver;.\src
  asm include: .\src
  group USER
    ./src/: main.c delay.c
    ../../../../../Driver/: a96T428_gpio.c a96T428_clock.c a96T428_usart2_spi.c a96T428_usi_usart.c
  group STARTUP
    ./src/: startup.a51
